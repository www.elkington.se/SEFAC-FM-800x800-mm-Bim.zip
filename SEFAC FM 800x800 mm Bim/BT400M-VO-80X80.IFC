Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: BT400M-VO-80X80.IFC
Time: 2019-03-28T14:52:14
Author: com2it
Organization: Hewlett-Packard Company
Written by: SwIFC
Made in: SolidWorks 2015

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: BT400M-EX-VO-80-A (2)
In: Default Storey
Name
BT400M-EX-VO-80-A | PSet_Mass_Property - Mass Measure: 35.4008; Area Measure: 3.049 m2; Volume Measure: 0.0045383 m3
BT400M-EX-VO-80-A
